Commit message: Everything works now -Lorenzo

File: threedof/threedof_description/urdf/threedof_old.urdf (robot description, URDF)
Before this commit: robot threedof, 6 links, 5 joints
Joints:
- joint tip_joint: origin xyz=0.316 -0.068 0 rpy=0 0 0 -> xyz=0.316 0 0 rpy=0 0 0
